options:
  parameters:
    generate_options: no_gui
    id: noname
    output_language: python
    title: collision_experiments
  states: {}

blocks:
- name: band
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: bw
  id: variable
  parameters:
    value: 500e3/4
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 2**sf/bw > 16e-3
  states: {}
- name: lora_gt_id
  id: variable
  parameters:
    value: '101'
  states: {state: disabled}
- name: lora_gt_id
  id: variable
  parameters:
    value: '102'
  states: {state: disabled}
- name: lora_gt_id
  id: variable
  parameters:
    value: '103'
  states: {state: disabled}
- name: lora_gt_id
  id: variable
  parameters:
    value: '104'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: pyramid_gt_id
  id: variable
  parameters:
    value: '201'
  states: {state: disabled}
- name: pyramid_gt_id
  id: variable
  parameters:
    value: '202'
  states: {state: disabled}
- name: pyramid_gt_id
  id: variable
  parameters:
    value: '203'
  states: {state: disabled}
- name: pyramid_gt_id
  id: variable
  parameters:
    value: '204'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scala_gt_id
  id: variable
  parameters:
    value: '301'
  states: {state: disabled}
- name: scala_gt_id
  id: variable
  parameters:
    value: '302'
  states: {state: disabled}
- name: scala_gt_id
  id: variable
  parameters:
    value: '303'
  states: {state: disabled}
- name: scala_gt_id
  id: variable
  parameters:
    value: '304'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: lora_decode_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    spreading_factor: sf
  states: {}
- name: lora_decode_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    spreading_factor: sf
  states: {}
- name: lora_demod_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    fft_factor: '16'
    fs_bw_ratio: '2'
    g_id: lora_gt_id
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: sf
  states: {}
- name: lora_pyramid_demod_0
  id: lora_pyramid_demod
  parameters:
    beta: '25.0'
    fft_factor: '4'
    fs_bw_ratio: '2'
    g_id: pyramid_gt_id
    low_data_rate: ldr
    spreading_factor: sf
    threshold: '0.005'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2+20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_0
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2+20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_0
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*bw/samp_rate_0
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: bw/samp_rate_0
    type: ccf
  states: {}
- name: scala_detector_0
  id: scala_detector
  parameters:
    g_id: scala_gt_id
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate_0
    center_freq0: band
    dc_offs_enb0: '""'
    dev_addr: serial=3189696
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate_0
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate_0
    center_freq0: band
    dc_offs_enb0: '""'
    dev_addr: serial=31E2BEA
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate_0
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate_0
    center_freq0: band
    dc_offs_enb0: '""'
    dev_addr: serial=3189EE7
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate_0
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate_0
    center_freq0: band
    dc_offs_enb0: '""'
    dev_addr: serial=31E2BFC
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate_0
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [lora_decode_0, header, lora_pyramid_demod_0, header]
- [lora_decode_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0_0, header, lora_demod_0, header]
- [lora_decode_0_0, out, blocks_message_debug_0, print_pdu]
- [lora_demod_0, out, lora_decode_0_0, in]
- [lora_pyramid_demod_0, out, lora_decode_0, in]
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_pyramid_demod_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', scala_detector_0, '0']
- [scala_detector_0, '0', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0_0, '0', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0_0_0, '0', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0_1, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0_1, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
